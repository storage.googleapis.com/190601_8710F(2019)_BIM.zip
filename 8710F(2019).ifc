Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-10T15:56:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 10 15:56:42 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{8E9005E0-87CD-45C4-869D-F01290381333}\ifc * Database version: 5507 * Database creation date: Mon Jun 10 15:56:41 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 10 15:56:41 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 10 15:56:41 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8710F Washbasin faucet, 3 V, 8710F:8710F Washbasin faucet, 3 V:355508
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 169.508 mm; FaucetNominalHeight: 151.863 mm; FaucetNominalWidth: 75.4653 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 317.5 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm; Projection: 118 mm
Type - Electrical(Type) - Battery: AA 1.5 V Lithium x 4; Operating Voltage: 3 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8710F; ConvergoRefNr: 0087-1906-0015-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basin and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 07/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150073229; EMC Directive: 2004/108/EY; EN Standard: EN 15091; LVI Number: 6110150; Noise Class: I (ISO 3822); NRF Number: 4203657; Protection Class: IP 44; RSK Number: 8348036; STF Certificate: VTT-RTH-00006-16; URL STF: http://static.oras.com/STF/8710F; VVS Number: 704231514
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/8710F; Catalog Drawing URL: http://static.oras.com/catdrw/8710F; Class: Tiptronic, battery-operated; Dimension Drawing URL: http://static.oras.com/dimdrw/8710F; FDV Document URL: http://www.oras.com/datasheet/8710F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/8710F; Group: Washbasin faucets; Long Marketing: Washbasin faucet with fixed spout and a swivel aerator. Faucet is opened by pressing gently on top of it, after which the faucet is open for 6 sec. (Factory setting) By pressing on top of the faucet for one second, the faucet stays open for one minute. By pressing on top of the faucet for 4 seconds, the faucet goes into cleaning mode and remains closed for 20 seconds. Easy to use temperature control handle operates also as a flow controller. Battery operated 3 V. Design by Rodrigo Torres. F = with flexible pipes; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 8710F Washbasin faucet, 3 V; Name_en: 8710F Washbasin faucet, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 393 x 193 x 82; Package Weight: 1.398 kg; Product Code: 8710F; Product Datasheet: https://www.oras.com/datasheet/8710F/en; Product Family: ALESSI Sense by Oras; Product Image URL: http://static.oras.com/image/8710F; Product URL: http://static.oras.com/8710F; Type Name: 8710F Washbasin faucet, 3 V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Aerator: Swivel aerator; Automatic Flush: off (off/12/24/48/72 h); Automatic Flush Period: 30 s (10-600 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation and Maintenance: http://static.oras.com/manual/8710F; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 6; Number of Shower Sprays: 1 spray; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.oras.com/sp/8710F; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome/White; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8710F; Features: Tiptronic, battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8710F; Name: 8710F Washbasin faucet, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 75x170x150 mm / Hand shower: 55x70x320 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8710F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8710F Washbasin faucet, 3 V
Constraints - FaucetDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0510939 m2; Volume: 0.00194734 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8710F: 8710F Washbasin faucet, 3 V; Family and Type: 8710F: 8710F Washbasin faucet, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8710F: 8710F Washbasin faucet, 3 V; Type Id: 8710F: 8710F Washbasin faucet, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
